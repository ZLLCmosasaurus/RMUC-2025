# Keil uVision project FSBB_V8.uvprojx, settings and files
target FSBB_V8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FSBB_V8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;../Hardware/Congfig;../Hardware/USER;../Hardware/Device;../Hardware/Driver;../Hardware/Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c hrtim.c i2c.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_can.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Congfig
    ../Hardware/Congfig/: config.cpp config.h
  group Device
    ../Hardware/Device/: dvc_dwt.cpp dvc_dwt.h
  group Driver
    ../Hardware/Driver/: drv_can.cpp drv_can.h drv_dwt.cpp drv_dwt.h drv_i2c.cpp drv_i2c.h drv_math.cpp drv_math.h drv_tim.cpp drv_tim.h drv_uart.cpp drv_uart.h
  group Task
    ../Hardware/Task/: tsk_config_and_callback.cpp tsk_config_and_callback.h
  group USER
    ../Hardware/USER/: Buzzer.cpp Buzzer.h Communication.cpp Communication.h Key.cpp Key.h Led.cpp Led.h Measure.cpp Measure.h PID.cpp PID.h Power_Control.cpp Power_Control.h TIMER.cpp TIMER.h
software components: CMSIS:CORE 4.3.0
